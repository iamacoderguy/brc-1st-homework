## br-ext/Config.in
```kconfig
menu "External options"
  source "$BR2_EXTERNAL_BRC1ST_PATH/package/myhello/Config.in"
endmenu
```
